# Keil uVision project ess_smart_ct.uvprojx, settings and files
target ess_smart_ct_Debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HC32F334JATI HDSC
  pack: HDSC.HC32F334.1.1.0
  cpu: IROM1(0x0,0x20000) IROM2(0x3000000,0x1800) IRAM1(0x1FFFC000,0x8000) IRAM2(0x200F0000,0x1000) CPUTYPE("Cortex-M4") FPU2 CLOCK(8000000) ESEL ELITTLE
  output: ess_smart_ct +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L
  c flags: OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __DEBUG,HC32F334,USE_DDL_DRIVER,ARM_MATH_CM4,__TARGET_FPU_VFP,__FPU_PRESENT=1
  c include: .\common;.\driver\src;.\driver\inc;..\app\inc;..\app\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000 size 0x20000
  memory RVCT5: ROM 0x3000000 size 0x1800
  memory RVCT9: RAM 0x1fffc000 size 0x8000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  link misc: --keep=*Handler
  group common
    ./: startup_hc32f334.s
    ./common/: system_hc32f334.c
  group driver
    ./driver/src/: hc32_ll.c hc32_ll_icg.c hc32_ll_utility.c hc32_ll_pwc.c hc32_ll_sram.c hc32_ll_efm.c hc32_ll_clk.c hc32_ll_gpio.c hc32_ll_fcg.c hc32_ll_aos.c hc32_ll_cmp.c hc32_ll_interrupts.c hc32_ll_adc.c hc32_ll_tmr0.c hc32_ll_usart.c hc32_ll_spi.c hc32_ll_emb.c hc32_ll_mcan.c hc32_ll_hrpwm.c hc32_ll_i2c.c hc32_ll_dma.c hc32_ll_tmr6.c
  group app
    ../app/src/: main.c sub1g.c mmi.c grid.c debug.c board.c eeprom.c flash.c ota_max.c fft.c at_parser.c crypto.c device_register.c ml307r.c uart_at.c iot.c
target ess_smart_ct_Release (5060020::V5.06 (build 20)::ARMCC)
  device: HC32F334JATI HDSC
  pack: HDSC.HC32F334.1.1.0
  cpu: as above
  output: ess_smart_ct +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: HC32F334,USE_DDL_DRIVER,
  c include: .\common;.\source;.\driver\inc;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x3000000 size 0x1800
  memory RVCT9: RAM 0x1fffc000 size 0x8000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  link misc: --keep=*Handler
software components: CMSIS:DSP 1.5.2
